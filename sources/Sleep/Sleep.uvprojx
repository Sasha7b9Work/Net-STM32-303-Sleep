# Keil uVision project Sleep.uvprojx, settings and files
target Debug (6210000::V6.21::.\ARMCLANG539)
  device: STM32F303CBTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x0000A000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MS-1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 wLevel=2
  c define: USE_HAL_DRIVER, STM32F303xC, DEBUG
  c include: .\src;.\src\Hardware\HAL;.\src\Hardware\CDC;..\common\STM32Cube_F3\Drivers\STM32F3xx_HAL_Driver\Inc;..\common\STM32Cube_F3\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\common\STM32Cube_F3\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\common\STM32Cube_F3\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\common\STM32Cube_F3\Drivers\CMSIS\Core\Include;..\common\STM32Cube_F3\Drivers\CMSIS\Device\ST\STM32F3xx\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group STM32F3
    ../common/STM32Cube_F3/Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_pcd.c stm32f3xx_hal_rcc.c stm32f3xx_hal_spi.c stm32f3xx_hal_uart.c stm32f3xx_hal_dma.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_adc.c stm32f3xx_hal_i2c.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_rtc_ex.c stm32f3xx_ll_usb.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_wwdg.c stm32f3xx_hal_iwdg.c
  group src
    ./src/: main.h stm32f3xx_hal_conf.h stm32f3xx_it.h system_stm32f3xx.c startup_stm32f334x8.s main.cpp stm32f3xx_hal_msp.cpp stm32f3xx_it.cpp
target Release (6210000::V6.21::.\ARMCLANG539)
  device: STM32F303CBTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: as above
  output: MS-1 +hex
  c flags: Optim=7 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 wLevel=2
  c define: USE_HAL_DRIVER, STM32F303xC
  c include: .\src;.\src\Hardware\HAL;.\src\Hardware\CDC;..\common\STM32Cube_F3\Drivers\STM32F3xx_HAL_Driver\Inc;..\common\STM32Cube_F3\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\common\STM32Cube_F3\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\common\STM32Cube_F3\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\common\STM32Cube_F3\Drivers\CMSIS\Core\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
